# Autodesk Inventor assembly: 520145_AC-SCM7U-BT-L
## iProperties
Created: 2011-05
Part Number: 520145_AC-SCM7U-BT-L
Document SubType Name: Assembly
Designer: seisen
Author: seisen
